# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F450IK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.1.0.0
  cpu: IROM(0x08000000,0x0300000) IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F4XX,OC_SERVER,OC_IPV4
  c include: ..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\config;..\..\kernel\cmsis;..\..\kernel\cpu\arm\cortex-m4;..\..\kernel\link\keil;..\..\platform\GD32F450i-EVAL;..\..\example\include;..\..\gd32firmware\Library\Firmware\GD32F4xx_standard_peripheral\Include;..\..\gd32firmware\Library\Utilities;..\..\gd32firmware\demo\inc;..\..\gd32firmware\Third_party\lwip-1.4.1\src\include;..\..\gd32firmware\Third_party\lwip-1.4.1\src\include\ipv4;..\..\gd32firmware\Third_party\lwip-1.4.1\src\include\netif;..\..\gd32firmware\Third_party\lwip-1.4.1\src\include\lwip;..\..\gd32firmware\Third_party\lwip-1.4.1\port\GD32F4xx;..\..\gd32firmware\Third_party\lwip-1.4.1\port\GD32F4xx\FreeRTOS;..\..\gd32firmware\Third_party\lwip-1.4.1\port\GD32F4xx\arch;..\..\gd32firmware\Library\Firmware\CMSIS;..\..\microcoap;..\..\iotivity-constrained\include;..\..\iotivity-constrained\messaging\coap;..\..\iotivity-constrained\security;..\..\iotivity-constrained\util;..\..\iotivity-constrained\port;..\..\iotivity-constrained\deps\tinycbor\src;..\..\iotivity-constrained\deps\tinydtls;..\..\iotivity-constrained;..\..\iotivity-constrained\api;..\..\iotivity-constrained\port\liteos;..\..\gd32firmware\Third_party\lwip-1.4.1\src\api;..\..\gd32firmware\Third_party\lwip-1.4.1\src\core\ipv6;..\..\iotivity-constrained\deps\tinycbor\examples;..\..\iotivity-constrained\deps\tinycbor\tools\cbordump;..\..\iotivity-constrained\deps\tinycbor\tools\json2cbor
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\platform\GD32F450i-EVAL\GD32F450-LiteOS.sct
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group cpu/cm4
    ../../kernel/cpu/arm/cortex-m4/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group platform/gd32f450i
    ../../platform/GD32F450i-EVAL/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group gd32f450bsp
    ../../gd32firmware/Library/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
    ../../gd32firmware/Library/Utilities/: gd32f450i_eval.c
    ../../gd32firmware/demo/src/: gd32f4xx_enet_eval.c system_gd32f4xx.c gd32f4xx_it.c hello_gigadevice.c netconf.c tcp_client.c udp_echo.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_interrupt.c los_api_event.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c
  group startup
    ../../gd32firmware/Library/Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f4xx.s
  group lwip
    ../../gd32firmware/Third_party/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../gd32firmware/Third_party/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../gd32firmware/Third_party/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../gd32firmware/Third_party/lwip-1.4.1/src/netif/: etharp.c
  group lwip_port
    ../../gd32firmware/Third_party/lwip-1.4.1/port/GD32F4xx/FreeRTOS/: ethernetif.c sys_arch.c
  group microcoap
    ../../microcoap/: coap.c endpoints.c coap_liteos_port.c
  group user
    ../../user/: main.c
  group iotivity/api
    ../../iotivity-constrained/api/: oc_base64.c oc_blockwise.c oc_buffer.c oc_client_api.c oc_collection.c oc_core_res.c oc_discovery.c oc_helpers.c oc_main.c oc_network_events.c oc_rep.c oc_ri.c oc_server_api.c oc_uuid.c
  group iotivity/apps
    ../../iotivity-constrained/apps/: simpleserver.c
  group iotivity/messaging/coap
    ../../iotivity-constrained/messaging/coap/: coap.c engine.c observe.c separate.c transactions.c
  group iotivity/security
    ../../iotivity-constrained/security/: oc_acl.c oc_cred.c oc_doxm.c oc_dtls.c oc_pstat.c oc_store.c oc_svr.c
  group iotivity/uitl
    ../../iotivity-constrained/util/: oc_etimer.c oc_list.c oc_memb.c oc_mmem.c oc_process.c oc_timer.c
  group iotivity/deps/tinycbor/src
    ../../iotivity-constrained/deps/tinycbor/src/: cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c cborpretty.c cbortojson.c open_memstream.c
  group iotivity/port/liteos
    ../../iotivity-constrained/port/liteos/: abort.c clock.c ipadapter.c random.c storage.c
